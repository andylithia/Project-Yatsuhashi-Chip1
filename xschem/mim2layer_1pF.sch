v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/code_shown.sym} 40 -50 0 0 {name=s1 only_toplevel=false value="X0 TOP BOT sky130_fd_pr__cap_mim_m3_1 l=2e+07u w=2.4e+07u
C0 TOP BOT 43.01fF
C1 TOP VSUBS 2.69fF 
C2 BOT VSUBS 10.38fF 

"}
C {devices/iopin.sym} -110 0 0 0 {name=p1 lab=TOP}
C {devices/iopin.sym} -110 40 0 0 {name=p3 lab=BOT}
C {devices/iopin.sym} -110 60 0 0 {name=p4 lab=VSUBS}
